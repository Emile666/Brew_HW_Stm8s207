<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\brew_stm8s207.ewp</path>
    </project>
    <batchBuild />
</workspace>
